# IAR project rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CM4F; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\cfg; ..\..\..\..\cfg\freertos\800
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\cfg; ..\..\..\..\cfg\freertos\800
  OBJCOPY.OOCOutputFile: rtos.srec
  ILINK.IlinkOutputFile: rtos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\cfg\freertos\800\cm4f
  ICCARM.CCOptLevel: 1
  AARM.AUserIncludes: ..\..\..\..\cfg\freertos\800\cm4f
  group (top)
    ../../../../ext/freertos/800/Source/: croutine.c list.c queue.c tasks.c timers.c
  group cm4f
    ../../../../ext/freertos/800/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
