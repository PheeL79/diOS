<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\hal\olimex_stm32_p407\iar710\hal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\osal\cm4f\iar710\osal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtos\cm4f\iar710\rtos.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Debug FLASH</name>
      <member>
        <project>hal</project>
        <configuration>Debug FLASH</configuration>
      </member>
      <member>
        <project>rtos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>osal</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release FLASH</name>
      <member>
        <project>hal</project>
        <configuration>Release FLASH</configuration>
      </member>
      <member>
        <project>rtos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>osal</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug SRAM</name>
      <member>
        <project>hal</project>
        <configuration>Debug SRAM</configuration>
      </member>
      <member>
        <project>rtos</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>osal</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release SRAM</name>
      <member>
        <project>hal</project>
        <configuration>Release SRAM</configuration>
      </member>
      <member>
        <project>rtos</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>osal</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


