# IAR project dios.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: dios.out
configuration Release FLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  ICCARM.CCDefines: CM4F
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\csp\cm4\CMSIS\400\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\400\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_StdPeriph_Driver\110\inc; ..\..\..\..\ext\fat_fs\0.10b\src; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\tst; ..\..\..\..\src\osal; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\fat_fs\0.10b\cm4f
  ICCARM.CCOptLevel: 0
configuration Release SRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib_d
    ../../../../lib/iar710/: cm4f_osal_d.a cm4f_rtos_d.a olimex_stm32_p407_hal_d.a
  group tst
    ../../../../src/tst/: test_main.c
    ../../../../ext/unity/src/: unity.c
