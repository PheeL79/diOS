# IAR project hal.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CM4F; STM32F407xx
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\fat_fs\0.10b\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\220\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\220\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\220\Class\MSC\Inc; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\hal; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\fat_fs\0.10b; ..\..\..\..\cfg\freertos\800; ..\..\..\..\cfg\olimex_stm32_p407
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hal.srec
  prebuild: ..\..\..\..\tls\revision_update.bat ..\..\..\..\src
  ILINK.IlinkOutputFile: hal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release FLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\..\src\hal; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\olimex_stm32_p407
  ICCARM.CCOptLevel: 1
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; STM32F407xx; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\fat_fs\0.10b\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Class\MSC\Inc; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\fat_fs\0.10b\cm4f; ..\..\..\..\cfg\freertos\800\cm4f; ..\..\..\..\cfg\olimex_stm32_p407
configuration Release SRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; VECT_TAB_SRAM; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  group (top)
    ../../../../src/hal/: hal.c
    ../../../../src/: printf-stdarg.c status.c
  group bsp/olimex_stm32_p407
    ../../../../src/hal/bsp/olimex_stm32_p407/: drv_audio_bsp.c drv_button.c drv_buzzer.c drv_led.c drv_media_bsp.c drv_mem_ext.c drv_trimmer.c hal_olimex_stm32_p407.c stm32f4xx_hal_msp.c
  group bsp/olimex_stm32_p407/system
    ../../../../src/hal/bsp/olimex_stm32_p407/: stm32f4xx_it.c system_stm32f4xx.c
  group com
    ../../../../src/hal/com/cs4344/: drv_audio_cs4344.c
  group csp
    ../../../../src/hal/csp/stm32f40xx/: drv_adc.c drv_adc3.c drv_dma.c drv_gpio.c drv_i2s.c drv_iwdg.c drv_media_sdcard.c drv_media_sdram.c drv_media_usbh.c drv_nvic.c drv_power.c drv_rtc.c drv_spi.c drv_timer.c drv_timer10.c drv_timer5.c drv_timer8.c drv_usart.c drv_usart6.c drv_usbd.c drv_usbd_msc.c drv_usbd_msc_desc.c drv_usbh.c drv_usbh_hid.c
  group csp/cmsis
    ../../../../ext/csp/cm4/CMSIS/401/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group csp/stm32_usb_device_library/class/hid
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/220/Class/HID/Src/: usbd_hid.c
  group csp/stm32_usb_device_library/class/msc
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/220/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group csp/stm32_usb_device_library/core
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/220/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group csp/stm32_usb_host_library/class/hid
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/220/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group csp/stm32_usb_host_library/class/msc
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/220/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group csp/stm32_usb_host_library/core
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/220/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group csp/stm32f4xx_hal_driver
    ../../../../ext/csp/stm32f4xx/STM32F4xx_HAL_Driver/110/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
