# IAR project hal.ewp, settings and files
configuration Debug FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CM4F; STM32F407xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\fat_fs\0.11a\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\141\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\AUDIO\Inc; ..\..\..\..\ext\lwip\201\system; ..\..\..\..\ext\lwip\201\src\include; ..\..\..\..\ext\lwip\201\src\include\netif; ..\..\..\..\ext\lwip\201\src\include\ipv4; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\tst; ..\..\..\..\src\hal; ..\..\..\..\src\hal\bsp; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\cfg; ..\..\..\..\cfg\fat_fs\0.11a; ..\..\..\..\cfg\lwip\201; ..\..\..\..\cfg\lwip\201\arch; ..\..\..\..\cfg\freertos\800
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hal.srec
  ILINK.IlinkOutputFile: hal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release FLASH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\141\Inc; ..\..\..\..\src\hal; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\olimex_stm32_p407
  ICCARM.CCOptLevel: 1
configuration Debug SRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; STM32F407xx; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\fat_fs\0.11a\src; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\141\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\MSC\Inc; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\cfg; ..\..\..\..\cfg\fat_fs\0.11a; ..\..\..\..\cfg\freertos\800; ..\..\..\..\cfg\olimex_stm32_p407
configuration Release SRAM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F; VECT_TAB_SRAM; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  group (top)
    ../../../../src/: common.c printf-stdarg.c ring_buffer.c status.c
    ../../../../src/hal/: hal.c
  group bsp/olimex_stm32_p407
    ../../../../src/hal/bsp/olimex_stm32_p407/: drv_audio_bsp.c drv_button.c drv_buzzer.c drv_media_bsp.c drv_mem_ext.c drv_trimmer.c hal_olimex_stm32_p407.c stm32f4xx_hal_msp.c
  group bsp/olimex_stm32_p407/system
    ../../../../src/hal/bsp/olimex_stm32_p407/: stm32f4xx_it.c system_stm32f4xx.c
  group com
    ../../../../com/cs4344/: drv_cs4344.c
    ../../../../com/ks8721bl/: drv_ks8721bl.c
  group csp
    ../../../../src/hal/csp/stm32f40xx/: drv_adc.c drv_adc3.c drv_crc.c drv_dma.c drv_eth.c drv_gpio.c drv_i2s.c drv_iwdg.c drv_media_sdcard.c drv_media_sdram.c drv_media_usbh.c drv_power.c drv_rtc.c drv_spi.c drv_timer.c drv_timer10.c drv_timer5.c drv_timer8.c drv_usart.c drv_usart6.c drv_usbd.c drv_usbd_audio.c drv_usbd_audio_desc.c drv_usbd_msc.c drv_usbd_msc_desc.c drv_usbh.c drv_usbh_hid.c
  group csp/cmsis
    ../../../../ext/csp/cm4/CMSIS/401/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group csp/stm32_usb_device_library/class/audio
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/241/Class/AUDIO/Src/: usbd_audio.c
  group csp/stm32_usb_device_library/class/hid
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/241/Class/HID/Src/: usbd_hid.c
  group csp/stm32_usb_device_library/class/msc
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/241/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group csp/stm32_usb_device_library/core
    ../../../../ext/csp/stm32f4xx/STM32_USB_Device_Library/241/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group csp/stm32_usb_host_library/class/hid
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/322/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group csp/stm32_usb_host_library/class/msc
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/322/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group csp/stm32_usb_host_library/core
    ../../../../ext/csp/stm32f4xx/STM32_USB_Host_Library/322/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group csp/stm32f4xx_hal_driver
    ../../../../ext/csp/stm32f4xx/STM32F4xx_HAL_Driver/141/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
