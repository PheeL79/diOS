# IAR project osal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CM4F; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\110\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\220\Class\MSC\Inc; ..\..\..\..\ext\fat_fs\0.10b\src; ..\..\..\..\ext\minini\1_2b; ..\..\..\..\ext\unity\210\src; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\osal\mm\tlsf; ..\..\..\..\src\osal\fs\fat_fs; ..\..\..\..\src\osal\sett\min_ini; ..\..\..\..\cfg; ..\..\..\..\cfg\freertos\800; ..\..\..\..\cfg\fat_fs\0.10b; ..\..\..\..\cfg\olimex_stm32_p407
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: osal.srec
  ILINK.IlinkOutputFile: osal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\inc; ..\..\..\..\src\osal\mem_mng\tlsf\inc; ..\..\..\..\cfg\freertos\800\cm4f; ..\..\..\..\cfg
  ICCARM.CCOptLevel: 1
  group (top)
    ../../../../src/osal/: os_debug.c os_driver.c os_environment.c os_event.c os_list.c os_message.c os_mutex.c os_power.c os_queue.c os_semaphore.c os_startup.c os_task.c os_task_sv.c os_time.c os_timer.c osal.c
  group fs
    ../../../../src/osal/fs/: os_file_system.c
  group fs/fat_fs
    ../../../../ext/fat_fs/0.10b/src/option/: ccsbcs.c unicode.c
    ../../../../src/osal/fs/fat_fs/: diskio.c syscall.c
    ../../../../ext/fat_fs/0.10b/src/: ff.c
  group mm
    ../../../../ext/freertos/800/Source/portable/MemMang/: heap_4.c
    ../../../../src/osal/mm/: os_memory.c
    ../../../../src/osal/mm/tlsf/: tlsf.c
  group net
    ../../../../src/osal/net/: os_network.c
  group sett
    ../../../../ext/minini/1_2b/: minIni.c
    ../../../../src/osal/sett/: os_settings.c
  group shell
    ../../../../src/osal/shell/: os_shell.c os_shell_commands_fs.c os_shell_commands_net.c os_shell_commands_std.c os_task_shell.c
  group tst
    ../../../../src/tst/: test_hal.c test_main.c test_osal.c
    ../../../../ext/unity/210/src/: unity.c
  group usb
    ../../../../src/osal/usb/: os_task_usbhd.c
