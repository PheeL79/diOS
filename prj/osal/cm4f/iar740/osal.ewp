# IAR project osal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CM4F; STM32F407xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\141\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\AUDIO\Inc; ..\..\..\..\ext\lwip\141_101\src\include; ..\..\..\..\ext\lwip\141_101\src\include\ipv4; ..\..\..\..\ext\lwip\141_101\src\include\netif; ..\..\..\..\ext\fat_fs\0.11a\src; ..\..\..\..\ext\minini\1_2b; ..\..\..\..\ext\unity\210\src; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\hal; ..\..\..\..\src\hal\bsp; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\osal\memory\tlsf; ..\..\..\..\src\osal\usb; ..\..\..\..\src\osal\network\lwip; ..\..\..\..\src\osal\network\lwip\arch; ..\..\..\..\src\osal\filesystem; ..\..\..\..\src\osal\filesystem\fat_fs; ..\..\..\..\src\osal\settings\min_ini; ..\..\..\..\cfg; ..\..\..\..\cfg\freertos\800; ..\..\..\..\cfg\lwip\141_101; ..\..\..\..\cfg\fat_fs\0.11a
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: osal.srec
  ILINK.IlinkOutputFile: osal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\inc; ..\..\..\..\src\osal\mem\tlsf; ..\..\..\..\cfg\freertos\800\cm4f; ..\..\..\..\cfg
  ICCARM.CCOptLevel: 1
  group (top)
    ../../../../src/osal/: os_driver.c os_environment.c os_list.c os_mailbox.c os_mutex.c os_power.c os_queue.c os_semaphore.c os_startup.c os_task.c os_task_sv.c os_time.c os_timer.c os_trigger.c osal.c
  group audio
    ../../../../src/osal/audio/: os_audio.c os_task_audio.c
  group debug
    ../../../../src/osal/debug/: os_debug.c os_task_log.c
  group filesystem
    ../../../../src/osal/filesystem/: os_file_system.c os_task_fs.c
  group filesystem/fat_fs
    ../../../../ext/fat_fs/0.11a/src/option/: ccsbcs.c unicode.c
    ../../../../src/osal/filesystem/fat_fs/: diskio.c syscall.c
    ../../../../ext/fat_fs/0.11a/src/: ff.c
  group memory
    ../../../../ext/freertos/800/Source/portable/MemMang/: heap_4.c
    ../../../../src/osal/memory/: os_memory.c
    ../../../../src/osal/memory/tlsf/: tlsf.c
  group network
    ../../../../src/osal/network/: os_network.c os_task_net.c
  group network/lwip/api
    ../../../../ext/lwip/141_101/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../../ext/lwip/141_101/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/core/ipv4
    ../../../../ext/lwip/141_101/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/netif
    ../../../../ext/lwip/141_101/src/netif/: etharp.c
    ../../../../src/osal/network/lwip/: sys_arch.c
  group settings
    ../../../../ext/minini/1_2b/: minIni.c
    ../../../../src/osal/settings/: os_settings.c
  group shell
    ../../../../src/osal/shell/: os_shell.c os_shell_commands_fs.c os_shell_commands_net.c os_shell_commands_std.c os_task_shell.c
  group test
    ../../../../src/tst/: test_hal.c test_main.c test_osal.c
    ../../../../ext/unity/210/src/: unity.c
  group usb
    ../../../../src/osal/usb/: os_task_usb.c
