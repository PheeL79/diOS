# IAR project osal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CM4F; STM32F407xx; USE_HAL_DRIVER; UNITY_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Include; ..\..\..\..\ext\csp\cm4\CMSIS\401\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\ext\csp\stm32f4xx\STM32F4xx_HAL_Driver\141\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Host_Library\322\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Core\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\HID\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\MSC\Inc; ..\..\..\..\ext\csp\stm32f4xx\STM32_USB_Device_Library\241\Class\AUDIO\Inc; ..\..\..\..\ext\lwip\201\src\include; ..\..\..\..\ext\lwip\201\src\include\ipv4; ..\..\..\..\ext\lwip\201\src\include\netif; ..\..\..\..\ext\fat_fs\0.11a\src; ..\..\..\..\ext\minini\1_2b; ..\..\..\..\ext\unity\240\src; ..\..\..\..\inc; ..\..\..\..\src; ..\..\..\..\src\tst; ..\..\..\..\src\hal; ..\..\..\..\src\hal\bsp; ..\..\..\..\src\hal\bsp\olimex_stm32_p407; ..\..\..\..\src\hal\csp\stm32f40xx; ..\..\..\..\src\osal\memory\tlsf; ..\..\..\..\src\osal\usb; ..\..\..\..\src\osal\network\lwip; ..\..\..\..\src\osal\network\lwip\arch; ..\..\..\..\src\osal\filesystem; ..\..\..\..\src\osal\filesystem\fat_fs; ..\..\..\..\src\osal\settings\min_ini; ..\..\..\..\cfg; ..\..\..\..\cfg\freertos\800; ..\..\..\..\cfg\lwip\201; ..\..\..\..\cfg\fat_fs\0.11a; ..\..\..\..\cfg\unity\240
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: osal.srec
  ILINK.IlinkOutputFile: osal.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CM4F
  ICCARM.CCIncludePath2: ..\..\..\..\ext; ..\..\..\..\ext\freertos\800\Source\include; ..\..\..\..\ext\freertos\800\Source\portable\IAR\ARM_CM4F; ..\..\..\..\inc; ..\..\..\..\src\osal\mem\tlsf; ..\..\..\..\cfg\freertos\800\cm4f; ..\..\..\..\cfg
  ICCARM.CCOptLevel: 1
  group (top)
    ../../../../src/osal/: os_driver.c os_environment.c os_list.c os_mailbox.c os_mutex.c os_power.c os_queue.c os_semaphore.c os_startup.c os_task.c os_task_sv.c os_time.c os_timer.c os_trigger.c osal.c
  group audio
    ../../../../src/osal/audio/: os_audio.c os_task_audio.c
  group debug
    ../../../../src/osal/debug/: os_debug.c os_task_log.c
  group filesystem
    ../../../../src/osal/filesystem/: os_file_system.c os_task_fs.c
  group filesystem/fat_fs
    ../../../../ext/fat_fs/0.11a/src/option/: ccsbcs.c unicode.c
    ../../../../src/osal/filesystem/fat_fs/: diskio.c syscall.c
    ../../../../ext/fat_fs/0.11a/src/: ff.c
  group memory
    ../../../../ext/freertos/800/Source/portable/MemMang/: heap_4.c
    ../../../../src/osal/memory/: os_memory.c
    ../../../../src/osal/memory/tlsf/: tlsf.c
  group network
    ../../../../src/osal/network/: os_network.c os_task_net.c os_task_net_dhcp.c
  group network/lwip/api
    ../../../../ext/lwip/201/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/apps/httpd
    ../../../../ext/lwip/201/src/apps/httpd/: fs.c httpd.c
  group network/lwip/apps/lwiperf
    ../../../../ext/lwip/201/src/apps/lwiperf/: lwiperf.c
  group network/lwip/apps/mqtt
    ../../../../ext/lwip/201/src/apps/mqtt/: mqtt.c
  group network/lwip/apps/netbiosns
    ../../../../ext/lwip/201/src/apps/netbiosns/: netbiosns.c
  group network/lwip/apps/snmp
    ../../../../ext/lwip/201/src/apps/snmp/: snmp_asn1.c snmp_asn1.h snmp_core.c snmp_core_priv.h snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_msg.h snmp_netconn.c snmp_pbuf_stream.c snmp_pbuf_stream.h snmp_scalar.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_dummy.c snmpv3_mbedtls.c snmpv3_priv.h
  group network/lwip/apps/sntp
    ../../../../ext/lwip/201/src/apps/sntp/: sntp.c
  group network/lwip/core
    ../../../../ext/lwip/201/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group network/lwip/core/ipv4
    ../../../../ext/lwip/201/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group network/lwip/core/ipv6
    ../../../../ext/lwip/201/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group network/lwip/netif
    ../../../../ext/lwip/201/src/netif/: ethernet.c lowpan6.c slipif.c
    ../../../../cfg/lwip/201/arch/: sys_arch.c
  group network/lwip/netif/ppp
    ../../../../ext/lwip/201/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group network/lwip/netif/ppp/polarssl
    ../../../../ext/lwip/201/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group settings
    ../../../../ext/minini/1_2b/: minIni.c
    ../../../../src/osal/settings/: os_settings.c
  group shell
    ../../../../src/osal/shell/: os_shell.c os_shell_commands_fs.c os_shell_commands_net.c os_shell_commands_std.c os_task_shell.c
  group test
    ../../../../src/tst/: test_hal.c test_main.c test_osal.c
    ../../../../ext/unity/240/src/: unity.c
  group usb
    ../../../../src/osal/usb/: os_task_usb.c
